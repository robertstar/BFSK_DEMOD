<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/vladimir/Work/ModelSim_PROJ/bfsk_tb/bfsk.bit</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>127</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/vladimir/Work/ModelSim_PROJ/bfsk.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>2500</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>6000</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
